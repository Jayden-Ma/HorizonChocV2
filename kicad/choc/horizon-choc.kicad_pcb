# Repository Jayden-Ma/HorizonChocV2

## KiCad design kicad/choc/horizon-choc.kicad_pcb

Parts:
BTN1: RESET; SW_Push_6mm
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52: D; D_SOD-123
H1, H2, H3, H4, H5, H6, H7, H8: Hole_Pad; Mount_M2
LOGO1: Logo-Bottom; Logo_Horizon_Small
LOGO2: Logo-Top; Logo_Horizon_H
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW21, SW22, SW23, SW24, SW25, SW26, SW27, SW28, SW29, SW30, SW31, SW32, SW33, SW34, SW35, SW36, SW37, SW38, SW39, SW40, SW41, SW42, SW43, SW44, SW45, SW46, SW47, SW48, SW49, SW50, SW51, SW52: SW_Push; Choc_V2_1.00u
U1: PRO-MICRO; Pro-Micro

Connections:
COL1: SW1.1, SW13.1, SW25.1, SW39.1, U1.19 (A2/PF5)
COL2: SW2.1, SW14.1, SW26.1, SW40.1, U1.18 (A1/PF6)
COL3: SW3.1, SW15.1, SW27.1, SW41.1, U1.17 (A0/PF7)
COL4: SW4.1, SW16.1, SW28.1, SW42.1, U1.16 (15/PB1)
COL5: SW5.1, SW17.1, SW29.1, SW43.1, U1.15 (14/PB3)
COL6: SW6.1, SW18.1, SW30.1, SW44.1, U1.14 (16/PB2)
COL7: SW31.1, SW45.1, U1.13 (10/PB6)
COL8: SW32.1, SW46.1, U1.12 (9/PB5)
COL9: SW7.1, SW19.1, SW33.1, SW47.1, U1.11 (8/PB4)
COL10: SW8.1, SW20.1, SW34.1, SW48.1, U1.10 (7/PE6)
COL11: SW9.1, SW21.1, SW35.1, SW49.1, U1.9 (6/PD7)
COL12: SW10.1, SW22.1, SW36.1, SW50.1, U1.8 (5/PC6)
COL13: SW11.1, SW23.1, SW37.1, SW51.1, U1.7 (4/PD4)
COL14: SW12.1, SW24.1, SW38.1, SW52.1, U1.6 (3/PD0)
GND: BTN1.2, U1.3 (GND), U1.4 (GND), U1.23 (GND)
unnamed: D1.2 (A), SW1.2
unnamed: D2.2 (A), SW2.2
unnamed: D3.2 (A), SW3.2
unnamed: D4.2 (A), SW4.2
unnamed: D5.2 (A), SW5.2
unnamed: D6.2 (A), SW6.2
unnamed: D7.2 (A), SW7.2
unnamed: D8.2 (A), SW8.2
unnamed: D9.2 (A), SW9.2
unnamed: D10.2 (A), SW10.2
unnamed: D11.2 (A), SW11.2
unnamed: D12.2 (A), SW12.2
unnamed: D13.2 (A), SW13.2
unnamed: D14.2 (A), SW14.2
unnamed: D15.2 (A), SW15.2
unnamed: D16.2 (A), SW16.2
unnamed: D17.2 (A), SW17.2
unnamed: D18.2 (A), SW18.2
unnamed: D19.2 (A), SW19.2
unnamed: D20.2 (A), SW20.2
unnamed: D21.2 (A), SW21.2
unnamed: D22.2 (A), SW22.2
unnamed: D23.2 (A), SW23.2
unnamed: D24.2 (A), SW24.2
unnamed: D25.2 (A), SW25.2
unnamed: D26.2 (A), SW26.2
unnamed: D27.2 (A), SW27.2
unnamed: D28.2 (A), SW28.2
unnamed: D29.2 (A), SW29.2
unnamed: D30.2 (A), SW30.2
unnamed: D31.2 (A), SW31.2
unnamed: D32.2 (A), SW32.2
unnamed: D33.2 (A), SW33.2
unnamed: D34.2 (A), SW34.2
unnamed: D35.2 (A), SW35.2
unnamed: D36.2 (A), SW36.2
unnamed: D37.2 (A), SW37.2
unnamed: D38.2 (A), SW38.2
unnamed: D39.2 (A), SW39.2
unnamed: D40.2 (A), SW40.2
unnamed: D41.2 (A), SW41.2
unnamed: D42.2 (A), SW42.2
unnamed: D43.2 (A), SW43.2
unnamed: D44.2 (A), SW44.2
unnamed: D45.2 (A), SW45.2
unnamed: D46.2 (A), SW46.2
unnamed: D47.2 (A), SW47.2
unnamed: D48.2 (A), SW48.2
unnamed: D49.2 (A), SW49.2
unnamed: D50.2 (A), SW50.2
unnamed: D51.2 (A), SW51.2
unnamed: D52.2 (A), SW52.2
RESET: BTN1.1, U1.22 (RST)
ROW1: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), U1.1 (TX0/PD3)
ROW2: D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), U1.2 (RX1/PD2)
ROW3: D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), D37.1 (K), D38.1 (K), U1.5 (2/PD1)
ROW4: D39.1 (K), D40.1 (K), D41.1 (K), D42.1 (K), D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), D47.1 (K), D48.1 (K), D49.1 (K), D50.1 (K), D51.1 (K), D52.1 (K), U1.20 (A3/PF4)
VCC: U1.21 (VCC)

Board: 2 copper layers, 252.0 x 68.0 mm, 108 parts (53 on the bottom side), 72 nets.

File BOM.csv:

"Id";"Designator";"Footprint";"Quantity";"Designation";"Supplier and ref";
1;"SW52,SW51,SW50,SW49,SW48,SW47,SW46,SW45,SW44,SW43,SW42,SW41,SW40,SW39,SW38,SW37,SW36,SW35,SW34,SW33,SW32,SW31,SW30,SW29,SW28,SW27,SW26,SW24,SW23,SW22,SW21,SW20,SW19,SW18,SW17,SW16,SW15,SW14,SW13,SW12,SW11,SW10,SW9,SW8,SW7,SW6,SW5,SW4,SW3,SW2,SW1,SW25";"Choc_V2_1.00u";52;"SW_Push";;;
2;"BTN1";"SW_Push_6mm";1;"RESET";;;
3;"U1";"Pro-Micro";1;"PRO-MICRO";;;
4;"LOGO1";"Logo_Horizon_Small";1;"Logo-Bottom";;;
5;"D25,D39,D13,D1,D2,D3,D4,D5,D6,D7,D8,D9,D10,D11,D12,D14,D15,D16,D17,D18,D19,D20,D21,D22,D23,D24,D26,D27,D28,D29,D30,D33,D34,D35,D36,D37,D38,D40,D41,D42,D43,D44,D45,D46,D47,D48,D49,D50,D51,D52,D31,D32";"D_SOD-123";52;"D";;;
6;"LOGO2";"Logo_Horizon_H";1;"Logo-Top";;;
